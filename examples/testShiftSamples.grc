options:
  parameters:
    generate_options: qt_gui
    id: testShiftSamples
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: int(32768)
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: vector_length
    srate: samp_rate
    type: complex
  states: {}
- name: shift_samples_module_shift_samples_0
  id: shift_samples_module_shift_samples
  parameters:
    number_of_samples_to_shift: '0'
    type: complex
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', shift_samples_module_shift_samples_0, '0']
- [shift_samples_module_shift_samples_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
