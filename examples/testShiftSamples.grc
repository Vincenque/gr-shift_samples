options:
  parameters:
    generate_options: qt_gui
    id: testShiftSamples
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: shift_samples
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '-int(1e6)'
    step: '1'
    stop: int(1e6)
    value: '0'
  states: {}
- name: sufix_of_sinks
  id: variable
  parameters:
    value: '""'
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: int(32768)
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: int(-vector_length/2)
    type: short
  states: {}
- name: blocks_argmax_xx_0_0_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: vector_length
  states: {}
- name: blocks_argmax_xx_0_0_0_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: vector_length
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: int(vector_length)
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: int(vector_length)
  states: {}
- name: blocks_complex_to_mag_0_0_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: int(vector_length)
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: int(vector_length/2)
    type: complex
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: int(vector_length/2)
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: int(vector_length)
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(vector_length)
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(vector_length)
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(vector_length)
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):

          def __init__(self, vectorLength = 32768):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Get one value from vector',
                  in_sig=[(np.complex64,vectorLength), np.short],
                  out_sig=[np.complex64]
              )
              self.vectorLength = vectorLength

          def work(self, input_items, output_items):
              #for portIndex in range(len(input_items)):
              #    for vectorIndex in range(len(input_items[portIndex])):
              #        print("input_items[",portIndex,"][",vectorIndex,"] =", input_items[portIndex][vectorIndex])
              maximumCorrelationIndex = input_items[1][len(input_items[1])-1]
              wantedValue = input_items[0][len(input_items[0])-1][maximumCorrelationIndex]
              output_items[0][0] = wantedValue
              return 1
    vectorLength: int(vector_length)
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: int(vector_length)
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vector_length)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: int(vector_length)
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vector_length)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: int(vector_length)
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vector_length)
  states: {}
- name: qtgui_number_sink_delay
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: '"Delay value "+sufix_of_sinks'
    name: ''
    type: short
  states: {}
- name: qtgui_number_sink_phase_difference
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: '"Phase Difference "+sufix_of_sinks'
    name: ''
    type: float
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.2'
    name: '"Delay "+sufix_of_sinks'
    vlen: int(vector_length)
    x_start: int(-vector_length/2)
    x_step: '1'
  states: {}
- name: shift_samples_module_shift_samples_0
  id: shift_samples_module_shift_samples
  parameters:
    number_of_samples_to_shift: shift_samples
    type: complex
    vlen: vector_length
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', qtgui_number_sink_delay, '0']
- [blocks_argmax_xx_0_0_0, '0', epy_block_1, '1']
- [blocks_argmax_xx_0_0_0, '1', blocks_null_sink_0_0_0, '0']
- [blocks_argmax_xx_0_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_argmax_xx_0_0_0_0, '1', blocks_null_sink_0_0_0_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_number_sink_phase_difference, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_complex_to_mag_0_0_0, '0', blocks_argmax_xx_0_0_0, '0']
- [blocks_complex_to_mag_0_0_0_0, '0', blocks_argmax_xx_0_0_0_0, '0']
- [blocks_delay_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_delay_1_0, '0', blocks_stream_to_vector_0_1_1_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', shift_samples_module_shift_samples_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_stream_to_vector_0_1_1, '0', blocks_complex_to_mag_0_0_0, '0']
- [blocks_stream_to_vector_0_1_1, '0', epy_block_1, '0']
- [blocks_stream_to_vector_0_1_1_0, '0', blocks_complex_to_mag_0_0_0_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_delay_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_delay_1_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_vector_0_1_1, '0']
- [epy_block_1, '0', blocks_complex_to_arg_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_1, '0', blocks_vector_to_stream_0, '0']
- [shift_samples_module_shift_samples_0, '0', fft_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
